# Keil uVision project ConductivityMeter.uvprojx, settings and files
target ConductivityMeter (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ConductivityMeter +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\led;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M4\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\User\BSP\ad9850;..\..\User\BSP\ds18b20;..\..\User\BSP\adc;..\..\User\BSP\ltdc\flash;..\..\User\BSP\ltdc\font;..\..\User\BSP\ltdc\lcd;..\..\User\BSP\ltdc\sdram;..\..\User\BSP\ltdc\touch;..\..\User\BSP\ltdc;..\..\User\BSP\tim;..\..\User;..\..\User\BSP\key;..\..\User\BSP\FATFS;..\..\User\BSP\sdio;..\..\User\BSP\usart;..\..\User\BSP\FATFS\option;..\..\User\BSP\touch;..\..\User\BSP\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DOC
    ../../Doc/: 必读说明.txt
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../USER/: stm32f4xx_it.c
    ../../User/: main.c
  group BSP
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/ad9850/: bsp_ad9850.c
    ../../User/BSP/ds18b20/: bsp_ds18b20.c
    ../../User/BSP/adc/: bsp_adc.c
    ../../User/BSP/ltdc/sdram/: bsp_sdram.c
    ../../User/BSP/ltdc/lcd/: bsp_lcd.c
    ../../User/BSP/ltdc/font/: fonts.c
    ../../User/BSP/ltdc/flash/: bsp_spi_flash.c
    ../../User/BSP/: bsp.c
    ../../User/BSP/tim/: bsp_basic_tim.c
    ../../User/BSP/FATFS/option/: cc936.c
    ../../User/BSP/FATFS/: diskio.c ff.c
    ../../User/BSP/sdio/: bsp_sdio_sd.c bsp_sd_write_read.c
    ../../User/BSP/usart/: bsp_debug_usart.c
    ../../User/BSP/touch/: bsp_i2c_touch.c gt9xx.c
    ../../User/BSP/key/: bsp_key_exti.c
